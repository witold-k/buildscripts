# this is just a dummy "bbclass" that is required by BBCLASSEXTEND
# PRIORITY = "5"
