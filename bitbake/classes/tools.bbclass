GENERATE_SOURCE = "${BUILDTOOLS_ROOTFS}/bin/generate-source"

CMAKE_OPTIONS += "\
-DGENERATE_SOURCE_BIN='${GENERATE_SOURCE}' \
"
